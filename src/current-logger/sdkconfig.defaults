## src/current-logger/sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8000
CONFIG_PTHREAD_TASK_STACK_SIZE_DEFAULT=20000
```
